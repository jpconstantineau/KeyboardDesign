# Repository jpconstantineau/KeyboardDesign

File README.md:

# KeyboardDesign
Keyboard PCB Design using KiCAD

## KiCad design ErgoSplit/ErgoSplit.kicad_pcb

Board: 2 copper layers, 116.2 x 94.8 mm, 42 parts (21 on the bottom side), 33 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: D; D_SOD123_axial-dual
K1, K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K15, K16, K17: KEYSW; Mx_Alps_100-dualside
K18: KEYSW; Mx_Alps_175-dualside
K19: TRRS; 4pin35mmAudio-dualsided
RESET1, RESET1#2: RESET; SW_SPST_TL3342
SJ1, SJ2: SOLDER_JUMPER_3
U1: ProMicro; Pro_Micro

Connections:
/col1: K1.1, K6.1, K11.1, U1.5
/col2: K2.1, K7.1, K12.1, U1.13
/col3: K3.1, K8.1, K13.1, K16.1, U1.14
/col4: K4.1, K9.1, K14.1, K17.1, U1.17
/col5: K5.1, K10.1, K15.1, K18.1, U1.19
/data: K19.3, U1.18
/row1: D1.1, D2.1, D3.1, D4.1, D5.1, U1.11
/row2: D6.1, D7.1, D8.1, D9.1, D10.1, U1.12
/row3: D11.1, D12.1, D13.1, D14.1, D15.1, U1.23
/row4: D16.1, D17.1, D18.1, U1.24
GND: RESET1.2, RESET1#2.2, SJ1.3, SJ2.3, U1.2, U1.15, U1.16
unnamed: D1.2, K1.2
unnamed: D2.2, K2.2
unnamed: D3.2, K3.2
unnamed: D4.2, K4.2
unnamed: D5.2, K5.2
unnamed: D6.2, K6.2
unnamed: D7.2, K7.2
unnamed: D8.2, K8.2
unnamed: D9.2, K9.2
unnamed: D10.2, K10.2
unnamed: D11.2, K11.2
unnamed: D12.2, K12.2
unnamed: D13.2, K13.2
unnamed: D14.2, K14.2
unnamed: D15.2, K15.2
unnamed: D16.2, K16.2
unnamed: D17.2, K17.2
unnamed: D18.2, K18.2
unnamed: K19.1, SJ2.2
unnamed: K19.4, SJ1.2
unnamed: RESET1.1, RESET1#2.1, U1.3
VCC: SJ1.1, SJ2.1, U1.4

## Commit log

2018-02-21 adding KB Files and Folders
